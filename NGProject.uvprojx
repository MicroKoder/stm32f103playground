# Keil uVision project NGProject.uvprojx, settings and files
target Target 1 (6160000::V6.16::ARMCLANG)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: NGProject
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=6 wLevel=2
  c define: STM32F103xB, HSE_VALUE=8000000U, __CHECK_DEVICE_DEFINES
  c include: .\src\cmsis;.\src
  asm include: .\src
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group cmsis
    ./src/cmsis/: system_stm32f1xx.c startup_stm32f103xb.s
  group src
    ./src/: main.c
